OECMAKE_C_FLAGS_RELEASE += " -ffast-math -mtune=cortex-a72"
OECMAKE_CXX_FLAGS_RELEASE += " -ffast-math -mtune=cortex-a72"

