SRC_URI = "git://github.com/WiringPi/WiringPi \
           file://0001-Add-initial-cross-compile-support.patch \
           "

SRCREV = "093e0a17a40e064260c1f3233b1ccdf7e4c66690"

