# Version and build configuration for TWINE on Elk Pi boards
PV = "0.2.1+${SRCREV}"
SRCREV = "635712f880e5ecedad6cf42a28be7c66c94d1cf5"
