# Twine source revision for sika

SRC_URI = "git://github.com/elk-audio/twine;protocol=https;nobranch=1"
SRCREV = "06c781819223b3cd247203f4b7bfe4b86c46d21c"

PV = "0.1.0+${SRCREV}"