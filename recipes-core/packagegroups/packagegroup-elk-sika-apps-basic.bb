SUMMARY = "Package group for packages needed by Sika"

inherit packagegroup

RDEPENDS_packagegroup-elk-sika-apps-basic = " \
    elk-startup-scripts \
    "
